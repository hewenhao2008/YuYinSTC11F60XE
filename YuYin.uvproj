# Keil uVision project YuYin.uvproj, settings and files
target 目标 1 (MCS-51)
  device: STC11F60XE STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: YuYin +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: C:\Keil\C51\INC
  group 源代码组 1
    ./: STARTUP.A51 YuYin.c DS18B20.c
